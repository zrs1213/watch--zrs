# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\firmware\cmsis\config;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\firmware\driver\src;..\hardware\inc;..\hardware\src;..\system\inc;..\system\src;..\third_lib\freertos\include;..\third_lib\freertos;..\third_lib\freertos\portable;..\app_lib\image;..\app_lib\font;..\app\inc;..\app\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/freertos
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/freertos/portable/: heap_4.c port.c FreeRTOSConfig.h
  group system/src
    ../system/src/: u_usart.c u_spi.c u_timer.c u_bsp_rcc_f4.c u_log.c
  group system/inc
    ../system/inc/: u_timer.h u_usart.h u_spi.h u_log.h u_bsp_rcc.h
  group hardware/inc
    ../hardware/inc/: DHT11.h TFT_LCD.h ST7789.h AT.h
  group hardware/src
    ../hardware/src/: AT.c DHT11.c TFT_LCD.c ST7789.c
  group app
    ../app/: main.c main.h u_header.h
  group app/image
    ../app_lib/image/: image.c image_home.c image_init.c tmp_cold.c tmp_hot.c tmp_warm.c we_cloudy.c we_heavy_rain.c we_late_night.c we_night.c we_rainy.c we_snowy.c we_sunny.c we_unknown.c wifi_no.c wifi_yes.c image.h
  group app/inc
    ../app/inc/: u_homepage.h u_initpage.h
  group app/src
    ../app/src/: u_initpage.c u_homepage.c
  group app/font
    ../app_lib/font/: font.h font16.c font22.c font24.c font32.c font44.c font48.c
